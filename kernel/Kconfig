## kernel/Kconfig
```kconfig
config KERNEL_HACK
	tristate "Kernel Hack Driver"
	default y
	help
	This is the kernel hack driver for android system.
```
